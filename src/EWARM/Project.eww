<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f103c8t6_cube.ewp</path>
  </project>
  <batchBuild />
</workspace>
